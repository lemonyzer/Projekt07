//---------------------------------------------------------------------------

#include <vcl.h>
#pragma hdrstop

#include "unt_controller.h"
//---------------------------------------------------------------------------
#pragma package(smart_init)
#pragma resource "*.dfm"
TForm1 *Form1;
//---------------------------------------------------------------------------
__fastcall TForm1::TForm1(TComponent* Owner)
	: TForm(Owner)
{

	x=0;
	y=0;

	for(int i=0;i<25;i++)
	{
		if(i==5 || i ==10 || i ==15 || i ==20)
		{
			y=0;
			x++;
		}
		left[i] = new TShape(this);
		left[i]->Shape = stCircle;
		left[i]->Width = 20;
		left[i]->Height = 20;
		left[i]->Left=24+(x*25);
		left[i]->Top=128+(y*25);
		InsertControl(left[i]);
		y++;
	}

	max= 255; 	// 2^8 -> 256 zustände

	RJoyX=128;	//	zentriert
	RJoyY=128;	//	zentriert
	LJoyX=128;	//	zentriert
	LJoyY=128;	//	zentriert


	rx = "00000000";
	ry = "00000000";
	lx = "00000000";
	ly = "00000000";

	rest=0;

}
//---------------------------------------------------------------------------
void __fastcall TForm1::FormDestroy(TObject *Sender)
{
	for(int i=0;i<25;i++)
	{
		delete left[i];
	}
}
//---------------------------------------------------------------------------
void __fastcall TForm1::Shape2MouseMove(TObject *Sender, TShiftState Shift,
      int X, int Y)
{
	int xl=X;
	int yl=Y;

	Label1->Caption = IntToBin2(X);
	Label2->Caption = IntToBin2(Y);

	for(int i=0;i<25;i++)
	{
		left[i]->Brush->Color = clWhite;
	}
	//###########################################################################
	//###########################################################################
	//###########################################################################
	if(X < 85)
	{
		if(Y < 85)
		{
			left[0]->Brush->Color = clRed;
		}
		else if(Y > 85 && Y < 2*85)
		{
			left[2]->Brush->Color = clRed;
		}
		else if(Y > 2*85)
		{
			left[4]->Brush->Color = clRed;
		}
	}
	//###########################################################################
	//###########################################################################
	//###########################################################################	//###########################################################################
	if(X > 85	&&
		X < 2*85 &&
		Y > 85	&&
		Y < 2*85)
	{
		left[12]->Brush->Color = clRed;
	}

	if(X > 85	&&
		X < 2*85 &&
		Y > 2*85)
	{
		left[14]->Brush->Color = clRed;
	}

	if(X > 85	&&
		X < 2*85 &&
		Y < 85)
	{
		left[10]->Brush->Color = clRed;
	}
	//###########################################################################
	//###########################################################################
	//###########################################################################
	if(X > 2*85	&&
		Y > 85	&&
		Y < 2*85)
	{
		left[22]->Brush->Color = clRed;
	}

	if(X > 2*85	&&
		Y > 2*85)
	{
		left[24]->Brush->Color = clRed;
	}

	if(X > 2*85	&&
		Y < 85)
	{
		left[20]->Brush->Color = clRed;
	}

}
//---------------------------------------------------------------------------
